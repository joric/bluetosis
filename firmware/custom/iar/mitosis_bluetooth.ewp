# IAR project mitosis_bluetooth.ewp, settings and files
configuration nrf51822_xxac (ARM)
  General.OGChipSelectEditMenu: nrf51822_xxac nRF51822_xxAC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: BLE_STACK_SUPPORT_REQD; NRF51822; BOARD_CUSTOM; NRF_SD_BLE_API_VERSION=2; S130; NRF51; SOFTDEVICE_PRESENT; SWI_DISABLE0
  ICCARM.CCIncludePath2: ..\..\config; ..\..\..\..\components; ..\..\..\..\components\ble\ble_advertising; ..\..\..\..\components\ble\ble_dtm; ..\..\..\..\components\ble\ble_racp; ..\..\..\..\components\ble\ble_services\ble_ancs_c; ..\..\..\..\components\ble\ble_services\ble_ans_c; ..\..\..\..\components\ble\ble_services\ble_bas; ..\..\..\..\components\ble\ble_services\ble_bas_c; ..\..\..\..\components\ble\ble_services\ble_cscs; ..\..\..\..\components\ble\ble_services\ble_cts_c; ..\..\..\..\components\ble\ble_services\ble_dfu; ..\..\..\..\components\ble\ble_services\ble_dis; ..\..\..\..\components\ble\ble_services\ble_gls; ..\..\..\..\components\ble\ble_services\ble_hids; ..\..\..\..\components\ble\ble_services\ble_hrs; ..\..\..\..\components\ble\ble_services\ble_hrs_c; ..\..\..\..\components\ble\ble_services\ble_hts; ..\..\..\..\components\ble\ble_services\ble_ias; ..\..\..\..\components\ble\ble_services\ble_ias_c; ..\..\..\..\components\ble\ble_services\ble_lbs; ..\..\..\..\components\ble\ble_services\ble_lbs_c; ..\..\..\..\components\ble\ble_services\ble_lls; ..\..\..\..\components\ble\ble_services\ble_nus; ..\..\..\..\components\ble\ble_services\ble_nus_c; ..\..\..\..\components\ble\ble_services\ble_rscs; ..\..\..\..\components\ble\ble_services\ble_rscs_c; ..\..\..\..\components\ble\ble_services\ble_tps; ..\..\..\..\components\ble\common; ..\..\..\..\components\ble\nrf_ble_qwr; ..\..\..\..\components\ble\peer_manager; ..\..\..\..\components\boards; ..\..\..\..\components\device; ..\..\..\..\components\drivers_nrf\adc; ..\..\..\..\components\drivers_nrf\clock; ..\..\..\..\components\drivers_nrf\common; ..\..\..\..\components\drivers_nrf\comp; ..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\components\drivers_nrf\i2s; ..\..\..\..\components\drivers_nrf\lpcomp; ..\..\..\..\components\drivers_nrf\pdm; ..\..\..\..\components\drivers_nrf\power; ..\..\..\..\components\drivers_nrf\ppi; ..\..\..\..\components\drivers_nrf\pwm; ..\..\..\..\components\drivers_nrf\qdec; ..\..\..\..\components\drivers_nrf\rng; ..\..\..\..\components\drivers_nrf\rtc; ..\..\..\..\components\drivers_nrf\saadc; ..\..\..\..\components\drivers_nrf\spi_master; ..\..\..\..\components\drivers_nrf\spi_slave; ..\..\..\..\components\drivers_nrf\swi; ..\..\..\..\components\drivers_nrf\timer; ..\..\..\..\components\drivers_nrf\twi_master; ..\..\..\..\components\drivers_nrf\twis_slave; ..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\components\drivers_nrf\usbd; ..\..\..\..\components\drivers_nrf\wdt; ..\..\..\..\components\libraries\bsp; ..\..\..\..\components\libraries\button; ..\..\..\..\components\libraries\crc16; ..\..\..\..\components\libraries\crc32; ..\..\..\..\components\libraries\csense; ..\..\..\..\components\libraries\csense_drv; ..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\components\libraries\fds; ..\..\..\..\components\libraries\fstorage; ..\..\..\..\components\libraries\gpiote; ..\..\..\..\components\libraries\hardfault; ..\..\..\..\components\libraries\hci; ..\..\..\..\components\libraries\led_softblink; ..\..\..\..\components\libraries\log; ..\..\..\..\components\libraries\log\src; ..\..\..\..\components\libraries\low_power_pwm; ..\..\..\..\components\libraries\mem_manager; ..\..\..\..\components\libraries\pwm; ..\..\..\..\components\libraries\queue; ..\..\..\..\components\libraries\scheduler; ..\..\..\..\components\libraries\sensorsim; ..\..\..\..\components\libraries\slip; ..\..\..\..\components\libraries\timer; ..\..\..\..\components\libraries\twi; ..\..\..\..\components\libraries\uart; ..\..\..\..\components\libraries\usbd; ..\..\..\..\components\libraries\usbd\class\audio; ..\..\..\..\components\libraries\usbd\class\cdc; ..\..\..\..\components\libraries\usbd\class\cdc\acm; ..\..\..\..\components\libraries\usbd\class\hid; ..\..\..\..\components\libraries\usbd\class\hid\generic; ..\..\..\..\components\libraries\usbd\class\hid\kbd; ..\..\..\..\components\libraries\usbd\class\hid\mouse; ..\..\..\..\components\libraries\usbd\class\msc; ..\..\..\..\components\libraries\usbd\config; ..\..\..\..\components\libraries\util; ..\..\..\..\components\softdevice\common\softdevice_handler; ..\..\..\..\components\softdevice\s130\headers; ..\..\..\..\components\softdevice\s130\headers\nrf51; ..\..\..\..\components\toolchain; ..\..\..\..\components\toolchain\cmsis\include; ..\..\..\..\external\segger_rtt; ..\..\..\..\components\proprietary_rf\gzll; ..\..\..\..\components\libraries\fifo
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  OBJCOPY.OOCOutputFile: nrf51822_xxac.hex
  postbuild: D:\Projects\mitosis-keyboard\nRF5_SDK_12.3.0_d7731ad\mitosis\mitosis-bluetooth\program.cmd
  ILINK.IlinkOutputFile: nrf51822_xxac.out
  ILINK.IlinkIcfFile: mitosis_bluetooth.icf
  ILINK.IlinkAdditionalLibs: D:\Projects\mitosis-keyboard\nRF5_SDK_12.3.0_d7731ad\components\proprietary_rf\gzll\iar\gzll_nrf51_iar.a; D:\Projects\mitosis-keyboard\nRF5_SDK_12.3.0_d7731ad\components\proprietary_rf\gzll\iar\gzll_nrf51_sd_resource_iar.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../config/: custom_board.h sdk_config.h
    ../../: main.c mitosis_ble_gzll.h mitosis_keymap.h
  group Board Definition
    ../../../../components/boards/: boards.c
  group Board Support
    ../../../../components/libraries/bsp/: bsp.c bsp_btn_ble.c bsp_nfc.c
  group Device
    ../../../../components/toolchain/iar/: iar_startup_nrf51.s
    ../../../../components/toolchain/: system_nrf51.c
  group nRF_BLE
    ../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../../../components/ble/ble_advertising/: ble_advertising.c
    ../../../../components/ble/peer_manager/: gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c pm_buffer.c pm_mutex.c security_dispatcher.c security_manager.c
  group nRF_BLE_Services
    ../../../../components/ble/ble_services/ble_bas/: ble_bas.c
    ../../../../components/ble/ble_services/ble_dis/: ble_dis.c
    ../../../../components/ble/ble_services/ble_hids/: ble_hids.c
  group nRF_Drivers
    ../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
  group nRF_Libraries
    ../../../../components/libraries/button/: app_button.c
    ../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_errors.c sdk_mapped_flags.c
    ../../../../components/libraries/fifo/: app_fifo.c
    ../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../components/libraries/timer/: app_timer_appsh.c app_timer_ble_gzll.c
    ../../../../components/libraries/uart/: app_uart_fifo.c retarget.c
    ../../../../components/libraries/crc16/: crc16.c
    ../../../../components/libraries/fds/: fds.c
    ../../../../components/libraries/fstorage/: fstorage.c
    ../../../../components/libraries/hardfault/: hardfault_implementation.c
    ../../../../components/libraries/sensorsim/: sensorsim.c
  group nRF_Log
    ../../../../components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_Segger_RTT
    ../../../../external/segger_rtt/: RTT_Syscalls_IAR.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c softdevice_handler_appsh.c
